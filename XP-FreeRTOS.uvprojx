# Keil uVision project XP-FreeRTOS.uvprojx, settings and files
target XP-FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XP-FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Module\LED;.\STM32;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ./App/: main.c
  group Modules
    ./Module/LED/: led.c
  group FreeRTOS-Src
    ./FreeRTOS-Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ./FreeRTOS-Source/portable/MemMang/: heap_4.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM4F/: port.c
  group STM32
    ./STM32/: SysTick.c
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:Startup 2.6.2
